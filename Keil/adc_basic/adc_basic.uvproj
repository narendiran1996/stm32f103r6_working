# Keil uVision project adc_basic.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: adc_basic +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: startup_stm32f10x_ld.s adc_basic_cpgm.c
    ../../Header_Files/: naren_gpio_func.c naren_gpio_func.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h naren_lcd_func.c naren_lcd_func.h
